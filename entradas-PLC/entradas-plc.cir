* EESchema Netlist Version 1.1 (Spice format) creation date: sáb 31 mar 2018 12:46:24 -03

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
XIC1  N-000056 GND GNDA N-000063 ? 4N28
R1  N-000057 N-000056 330
R2  N-000063 N-000055 10K
D2  N-000032 N-000057 LED
D1  GND N-000054 ZENER_24V
XIC2  N-000053 GND GNDA N-000039 ? 4N28
R5  N-000040 N-000053 330
R12  N-000039 N-000055 10K
D10  N-000027 N-000040 LED
D3  GND N-000005 ZENER_24V
XIC3  N-000018 GND GNDA N-000019 ? 4N28
R6  N-000017 N-000018 330
R13  N-000019 N-000055 10K
D11  N-000029 N-000017 LED
D4  GND N-000006 ZENER_24V
XIC4  N-000016 GND GNDA N-000010 ? 4N28
R7  N-000015 N-000016 330
R14  N-000010 N-000055 10K
D12  N-000044 N-000015 LED
D5  GND N-000045 ZENER_24V
XIC5  N-000012 GND GNDA N-000014 ? 4N28
R8  N-000011 N-000012 330
R15  N-000014 N-000055 10K
D13  N-000037 N-000011 LED
D6  GND N-000038 ZENER_24V
XIC6  N-000025 GND GNDA N-000026 ? 4N28
R9  N-000024 N-000025 330
R16  N-000026 N-000055 10K
D14  N-000003 N-000024 LED
D7  GND N-000007 ZENER_24V
XIC8  N-000023 GND GNDA N-000009 ? 4N28
R10  N-000022 N-000023 330
R17  N-000009 N-000055 10K
D15  N-000041 N-000022 LED
D8  GND N-000008 ZENER_24V
XIC7  N-000021 GND GNDA N-000001 ? 4N28
R11  N-000020 N-000021 330
R18  N-000001 N-000055 10K
D16  N-000043 N-000020 LED
D9  GND N-000042 ZENER_24V
K9  N-000054 N-000005 N-000006 CONN_3
K10  N-000045 N-000038 N-000007 CONN_3
K11  N-000008 N-000042 GND CONN_3
J1  N-000055 N-000063 N-000039 N-000019 N-000010 N-000014 N-000026 N-000001 N-000009 GNDA SIL10
R22  N-000007 N-000004 1K
R28  N-000003 N-000004 1K
K6  N-000007 N-000003 ? CONN_3
R21  N-000038 N-000002 1K
R27  N-000037 N-000002 1K
K5  N-000038 N-000037 ? CONN_3
R20  N-000045 N-000036 1K
R26  N-000044 N-000036 1K
K4  N-000045 N-000044 ? CONN_3
R19  N-000006 N-000035 1K
R25  N-000029 N-000035 1K
K3  N-000006 N-000029 ? CONN_3
R4  N-000005 N-000034 1K
R24  N-000027 N-000034 1K
K2  N-000005 N-000027 ? CONN_3
R3  N-000054 N-000033 1K
R23  N-000032 N-000033 1K
K1  N-000054 N-000032 ? CONN_3
R30  N-000043 N-000031 1K
R32  N-000042 N-000031 1K
K7  N-000043 N-000042 ? CONN_3
R29  N-000041 N-000030 1K
R31  N-000008 N-000030 1K
K8  N-000041 N-000008 ? CONN_3
P1  N-000055 GNDA CONN_2
D17  N-000055 N-000055 DIODE

.end
